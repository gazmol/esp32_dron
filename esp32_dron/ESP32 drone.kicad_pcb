# Repository gazmol/esp32_dron

## KiCad design esp32_dron/ESP32 drone.kicad_pcb

Parts:
C1, C4: 10u; C_0603_1608Metric
C2: 470pF; C_0603_1608Metric
C3: 2.2uF; C_0805_2012Metric
C5: 10uF; C_0603_1608Metric
C6, C11, C12, C13: 0.1uf; C_0603_1608Metric
C7, C9, C14: 10uf; C_0603_1608Metric
C8, C10, C15, C16, C17, C18: 1uf; C_0603_1608Metric
D1: SS34; D_SMA
D2, D3, D4, D5: 1N4148W; D_SOD-323
IC1: TP4056; SOIC127P600X175-9N; Manufacturer_Part_Number TP4056-42-ESOP8
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J4, J5, J6: Conn_01x02_Female; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J3: B2B-PH-SM4-TB(LF)(SN); JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
J8, J9: Conn_01x06_Female; PinHeader_1x06_P2.54mm_Vertical
LED1: POW_LED; LED_0603_1608Metric
LED2, LED3: CHG; LED_0603_1608Metric
LED4, LED5, LED6: LED; LED_0603_1608Metric
R1: 470R; R_0603_1608Metric
R2: 100K; R_0603_1608Metric
R3, R4: 1.3K; R_0603_1608Metric
R5: 47.5k; R_0603_1608Metric
R6: 22.1k; R_0603_1608Metric
R7, R10, R11, R12, R14, R18, R19, R20, R21: 10k; R_0603_1608Metric
R8, R9: 1k; R_0603_1608Metric
R13: 4.7k; R_0603_1608Metric
R15, R16, R17: 1K; R_0603_1608Metric
Rprog1: 3.3K; R_0603_1608Metric
SW1: K3-1280S-F1; slide switch spdt
T1, T2, T3, T4: SI2302DS-T1; SOT95P237X112-3N; Mouser Part Number 781-SI2302DS
U1, U4, U5: 100K; R_0603_1608Metric
U2: AO3401; SOT-23
U3: MIC5219-3.3YM5; SOT-23-5
U6: CP2102N-Axx-xQFN28; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm
U7: DDC114TU-7-F; SOT-363_SC-70-6
U8: ESP32-WROOM-32
U9: MPU-6050; MPU6050; Mouser Part Number 410-MPU-6050

Connections:
+3V3: C3.1, C4.1, C9.1, C10.1, C14.1, J8.2, R1.2, R10.2, R11.2, R12.2, R14.2, U3.5 (OUT), U8.2 (VDD), U9.8 (VLOGIC), U9.13 (VDD)
+5V: D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.1, U2.1 (G)
+BATT: C5.1, C15.1, C16.1, C17.1, C18.1, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), IC1.5 (BAT), J2.2, J3.1, J4.1, J5.1, J6.2, J9.2, U2.3 (D), U4.1
/ADC_BAT: U4.2, U5.1, U8.7 (IO35)
/D+: J1.A6 (D+), J1.B6 (D+), U6.4 (D+)
/D-: J1.A7 (D-), J1.B7 (D-), U6.5 (D-)
/DTR: U6.28 (~DTR), U7.2, U7.4
/EN: C11.1, R10.1, U7.6, U8.3 (EN)
/EXI5: U8.6 (IO34)
/EXIO1: U8.16 (IO13)
/EXIO2: U8.23 (IO15)
/EXIO3: U8.24 (IO2)
/EXIO4: U8.31 (IO19)
/IO0: R11.1, U7.3, U8.25 (IO0)
/LDO_H: R2.2, SW1.3 (C)
/LED_1: LED4.2 (A), U8.37 (IO23)
/LED_2: LED5.2 (A), U8.29 (IO5)
/LED_3: LED6.2 (A), U8.30 (IO18)
/MOT_1: R18.2, T1.1 (G), U8.26 (IO4)
/MOT_2: R19.2, T2.1 (G), U8.9 (IO33)
/MOT_3: R20.2, T3.1 (G), U8.8 (IO32)
/MOT_4: R21.2, T4.1 (G), U8.10 (IO25)
/RTS: U6.24 (~RTS), U7.1, U7.5
/RX: R8.2, U8.34 (RXD0/IO3)
/RXD2: J8.3, U8.27 (IO16)
/SCL: J8.6, R14.1, U8.36 (IO22), U9.23 (SCL)
/SDA: J8.5, R12.1, U8.33 (IO21), U9.24 (SDA)
/SRV_1: J9.3, U8.14 (IO12)
/SRV_2: J9.4, U8.13 (IO14), U9.12 (INT)
/SRV_3: J9.5, U8.12 (IO27)
/SRV_4: J9.6, U8.11 (IO26)
/TX: R9.2, U8.35 (TXD0/IO1)
/TXD2: J8.4, U8.28 (IO17)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, IC1.1 (TEMP), IC1.3 (GND), IC1.9 (EP), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.2, J8.1, J9.1, LED1.1 (K), R5.1, R13.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, Rprog1.2, SW1.1 (A), SW1.4, T1.2 (S), T2.2 (S), T3.2 (S), T4.2 (S), U1.2, U3.2 (GND), U5.2, U6.3 (GND), U6.29 (GND), U8.1 (GND), U8.15 (GND), U8.38 (GND), U8.39 (GND), U9.1 (CLKIN), U9.11 (FSYNC), U9.18 (GND)
LDO_EN: SW1.2 (B), U3.3 (EN)
unnamed: C15.2, D2.2 (A), J2.1, T1.3 (D)
unnamed: C16.2, D3.2 (A), J5.2, T2.3 (D)
unnamed: C17.2, D4.2 (A), J6.1, T3.3 (D)
unnamed: C18.2, D5.2 (A), J4.2, T4.3 (D)
unnamed: IC1.2 (PROG), Rprog1.1
unnamed: IC1.7 (~CHRG), R3.2
unnamed: IC1.6 (~STDBY), R4.2
unnamed: LED1.2 (A), R1.1
unnamed: LED2.1 (K), R3.1
unnamed: LED3.1 (K), R4.1
unnamed: LED4.1 (K), R15.2
unnamed: LED5.1 (K), R16.2
unnamed: LED6.1 (K), R17.2
unnamed: C2.1, U3.4 (BP)
unnamed: R9.1, U6.25 (RXD)
unnamed: R8.1, U6.26 (TXD)
unnamed: R5.2, R6.1, U6.8 (VBUS)
unnamed: C8.1, R7.2, U6.6 (VDD)
unnamed: R7.1, U6.9 (~RST)
unnamed: R13.2, U9.9 (AD0)
unnamed: C13.1, U9.20 (CPOUT)
unnamed: C12.1, U9.10 (REGOUT)
VBUS: C1.1, C6.1, C7.1, D1.1 (K), IC1.4 (VCC), IC1.8 (CE), LED2.2 (A), LED3.2 (A), R2.1, R6.2, U2.2 (S), U3.1 (IN), U6.7 (VREGIN)

Notes on the sheet:
SoC
medidor de voltaje de la bateria
IMU/giroscopio
controlador motores
cargador de bateria
Debug LEDs
Debug: USB - UART
pines extra
3.3V Regulador
On/Off

Board: 2 copper layers, 100.0 x 100.0 mm, 74 parts (0 on the bottom side), 53 nets.
